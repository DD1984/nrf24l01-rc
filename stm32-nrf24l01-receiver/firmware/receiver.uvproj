# Keil uVision project receiver.uvproj, settings and files
target Receiver (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: main +hex
  c flags: Optim=3 oTime=1 uC99=1 wLevel=2
  c include: .\startup;.\src
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group startup
    ./startup/: startup_stm32f030.s stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
  group src
    ./src/: main.c persistent_storage.c persistent_storage.h platform.h rc_receiver.c rc_receiver.h rf.c rf.h spi.c spi.h
